## boards/ISC/ISC_NRF54L15/board.yml
```yaml
board:
  name: ISC_NRF54L15
  vendor: ISC
  socs:
  - name: nrf54l15
    variants:
    - name: xip
      cpucluster: cpuflpr
```
